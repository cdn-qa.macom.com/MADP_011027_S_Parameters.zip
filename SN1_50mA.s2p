!Agilent Technologies,N5222A,MY51421700,A.10.00.00
!Agilent N5222A: A.10.00.00
!Date: Thursday, April 02, 2015 22:50:05
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   801 points, 10 MHz to 26.5 GHz, reference 50 ohm
!   highest |S21| = -22.49 dB at 11.8 GHz (marker M1); lowest = -31.3 dB at 241.8 MHz (marker M2)
!   lowest |S11| = -1.5 dB at 26.04 GHz (marker M3), VSWR 11.47, Z = 5.28 - j22.8 ohm
!   |S11| at or under -10 dB: nowhere
!   |S22| runs from -1.5 to -0.3 dB; largest |S21 - S12| = 0.00048
!   the Smith chart shows 21.7 GHz to 26.5 GHz only
!   S11 on the Smith chart (normalised r, x): 21.7 GHz: 0.09, -0.29; 22.63 GHz: 0.08, +0.39; 23.55 GHz: 0.26, +1.65; 24.51 GHz: 3.36, -5.52; 25.51 GHz: 0.15, -1.00; 26.5 GHz: 0.08, -0.13
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.3  -30.4  -30.4  -0.3
! 241.8 MHz  -0.4  -31.3  -31.4  -0.5
! 904 MHz  -0.6  -30.8  -30.8  -0.7
! 3.123 GHz  -0.7  -27.6  -27.6  -0.8
! 4.447 GHz  -0.7  -26.4  -26.4  -0.8
! 6.732 GHz  -1.0  -24.8  -24.8  -1.1
! 8.851 GHz  -1.1  -23.7  -23.7  -1.1
! 10.67 GHz  -1.1  -22.7  -22.7  -1.1
! 11.8 GHz  -1.1  -22.5  -22.5  -1.1
! 13.26 GHz  -1.2  -22.6  -22.6  -1.2
! 15.77 GHz  -1.1  -22.9  -22.9  -1.2
! 17.69 GHz  -1.1  -23.7  -23.7  -1.2
! 18.29 GHz  -1.1  -23.9  -23.9  -1.2
! 20.14 GHz  -1.4  -23.6  -23.6  -1.3
! 21.7 GHz  -1.4  -23.7  -23.7  -1.2
! 22.1 GHz  -1.3  -23.8  -23.8  -1.2
! 22.63 GHz  -1.2  -23.9  -23.9  -1.3
! 23.55 GHz  -1.2  -24.2  -24.2  -1.4
! 24.51 GHz  -1.4  -24.7  -24.7  -1.5
! 25.51 GHz  -1.3  -25.5  -25.5  -1.5
! 26.04 GHz  -1.5  -26.1  -26.1  -1.5
! 26.5 GHz  -1.3  -26.5  -26.5  -1.4
