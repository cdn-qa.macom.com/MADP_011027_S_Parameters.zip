!Agilent Technologies,N5222A,MY51421700,A.10.00.00
!Agilent N5222A: A.10.00.00
!Date: Thursday, April 02, 2015 22:44:10
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   801 points, 10 MHz to 26.5 GHz, reference 50 ohm
!   highest |S21| = -22.25 dB at 11.6 GHz (marker M1); lowest = -28.4 dB at 440.5 MHz (marker M2)
!   lowest |S11| = -1.5 dB at 20.97 GHz (marker M3), VSWR 11.92, Z = 9.45 - j55.5 ohm
!   |S11| at or under -10 dB: nowhere
!   |S22| runs from -1.6 to -0.4 dB; largest |S21 - S12| = 0.00062
!   the Smith chart shows 18.55 GHz to 23.39 GHz only
!   S11 on the Smith chart (normalised r, x): 18.55 GHz: 0.10, +0.67; 19.58 GHz: 0.88, +3.13; 20.54 GHz: 0.51, -2.24; 21.5 GHz: 0.10, -0.48; 22.43 GHz: 0.08, +0.23; 23.39 GHz: 0.20, +1.27
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.4  -27.1  -27.1  -0.4
! 175.6 MHz  -0.5  -28.3  -28.3  -0.4
! 440.5 MHz  -0.6  -28.4  -28.3  -0.6
! 1.169 GHz  -0.8  -27.9  -27.9  -0.7
! 3.255 GHz  -0.7  -25.9  -25.9  -0.6
! 4.447 GHz  -0.8  -25.3  -25.3  -0.8
! 8.851 GHz  -1.1  -23.3  -23.3  -1.0
! 10.57 GHz  -1.2  -22.5  -22.5  -1.1
! 11.6 GHz  -1.1  -22.3  -22.3  -1.2
! 13.26 GHz  -1.3  -22.5  -22.5  -1.3
! 15.71 GHz  -1.2  -22.7  -22.7  -1.2
! 17.69 GHz  -1.1  -23.6  -23.7  -1.2
! 18.55 GHz  -1.2  -23.8  -23.8  -1.3
! 19.58 GHz  -1.3  -23.6  -23.6  -1.4
! 20.54 GHz  -1.4  -23.5  -23.5  -1.3
! 20.97 GHz  -1.5  -23.5  -23.5  -1.3
! 21.5 GHz  -1.4  -23.6  -23.6  -1.2
! 22.1 GHz  -1.4  -23.7  -23.7  -1.3
! 22.43 GHz  -1.3  -23.8  -23.8  -1.3
! 23.39 GHz  -1.3  -24.1  -24.1  -1.3
! 24.61 GHz  -1.3  -24.7  -24.7  -1.5
! 26.5 GHz  -1.3  -26.4  -26.4  -1.5
