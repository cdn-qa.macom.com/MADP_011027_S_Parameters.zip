!Agilent Technologies,N5222A,MY51421700,A.10.00.00
!Agilent N5222A: A.10.00.00
!Date: Thursday, April 02, 2015 22:43:35
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   801 points, 10 MHz to 26.5 GHz, reference 50 ohm
!   highest |S21| = -21.44 dB at 11.17 GHz (marker M1); lowest = -26.2 dB at 26.5 GHz (marker M2)
!   lowest |S11| = -1.6 dB at 20.97 GHz (marker M3), VSWR 11.21, Z = 10 - j55.3 ohm
!   |S11| at or under -10 dB: nowhere
!   |S22| runs from -1.7 to -0.6 dB; largest |S21 - S12| = 0.00067
!   the Smith chart shows 18.52 GHz to 23.42 GHz only
!   S11 on the Smith chart (normalised r, x): 18.52 GHz: 0.11, +0.64; 19.58 GHz: 0.94, +3.11; 20.54 GHz: 0.54, -2.22; 21.5 GHz: 0.10, -0.48; 22.46 GHz: 0.09, +0.26; 23.42 GHz: 0.22, +1.34
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.7  -22.3  -22.3  -0.7
! 175.6 MHz  -0.7  -23.7  -23.7  -0.7
! 539.8 MHz  -0.9  -23.9  -23.9  -0.8
! 1.566 GHz  -1.0  -23.6  -23.5  -0.9
! 3.123 GHz  -1.0  -23.0  -22.9  -0.9
! 4.447 GHz  -1.0  -22.9  -22.9  -1.0
! 6.831 GHz  -1.3  -22.5  -22.5  -1.2
! 8.851 GHz  -1.3  -22.2  -22.2  -1.2
! 11.17 GHz  -1.3  -21.4  -21.5  -1.3
! 13.26 GHz  -1.4  -21.8  -21.8  -1.4
! 15.67 GHz  -1.3  -22.2  -22.2  -1.3
! 17.69 GHz  -1.2  -23.2  -23.2  -1.3
! 18.52 GHz  -1.3  -23.4  -23.4  -1.3
! 19.58 GHz  -1.4  -23.2  -23.2  -1.5
! 20.54 GHz  -1.5  -23.2  -23.2  -1.4
! 20.97 GHz  -1.6  -23.2  -23.2  -1.3
! 21.5 GHz  -1.5  -23.3  -23.3  -1.3
! 22.1 GHz  -1.5  -23.4  -23.5  -1.3
! 22.46 GHz  -1.4  -23.5  -23.5  -1.3
! 23.42 GHz  -1.4  -23.8  -23.8  -1.4
! 24.65 GHz  -1.4  -24.5  -24.5  -1.6
! 26.5 GHz  -1.4  -26.2  -26.2  -1.5
